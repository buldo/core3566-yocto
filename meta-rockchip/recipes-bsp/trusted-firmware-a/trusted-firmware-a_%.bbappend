COMPATIBLE_MACHINE:append:rk3566 = "|rk3566"
